options:
  parameters:
    generate_options: no_gui
    id: noaa21Recorder
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: interp
  id: variable
  parameters:
    value: '8'
  states: {}
- name: var_center_freq
  id: variable
  parameters:
    comment: |-
      Has center_freq value
      on start of script
      Can be changed in runtime
    value: center_freq
  states: {}
- name: antenna
  id: parameter
  parameters:
    comment: |-
      Value is assigned
      on start of script
    label: Antenna port on SDR
    short_id: a
    type: str
    value: '"RX2"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_path
    type: complex
  states: {}
- name: center_freq
  id: parameter
  parameters:
    comment: |-
      Value is assigned
      on start of script
    label: Center frequency
    short_id: f
    type: eng_float
    value: 01160e6
  states: {}
- name: file_path
  id: parameter
  parameters:
    comment: |-
      Value is assigned
      on start of script
    label: Path to output file
    short_id: p
    type: str
    value: '""'
  states: {}
- name: gain
  id: parameter
  parameters:
    comment: |-
      Value is assigned
      on start of script
    label: Gain
    short_id: g
    type: eng_float
    value: '12'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    fbw: '0.48'
    interp: interp
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: |-
      Value is assigned
      on start of script
    label: Sampling rate
    short_id: r
    type: eng_float
    value: 40e6
  states: {}
- name: satname
  id: parameter
  parameters:
    comment: |-
      Value is assigned
      on start of script
    label: Satellite name
    short_id: n
    type: str
    value: '""'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    center_freq0: var_center_freq
    gain0: gain
    samp_rate: samp_rate/interp*5
    sync: none
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    comment: |-
      Server to get requests
      of value change
    port: '64999'
  states: {}

connections:
- [rational_resampler_xxx_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-576-g9fca5db4
